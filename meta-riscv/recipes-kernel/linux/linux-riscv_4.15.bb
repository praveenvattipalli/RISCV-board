require recipes-kernel/linux/linux-riscv-common.inc

LINUX_VERSION ?= "4.15"

BRANCH = "mpfs"
SRCREV = "abd2a9748ceb94cc44a87130fcd1a68bb709ba74"
